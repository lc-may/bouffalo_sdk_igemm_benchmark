## defconfig
```kconfig
CONFIG_BFLB_LOG    =n
CONFIG_FREERTOS    =y
CONFIG_SHELL       =y
CONFIG_VSNPRINTF_FLOAT      =y
CONFIG_VSNPRINTF_FLOAT_EX   =y
CONFIG_VSNPRINTF_LONG_LONG  =y
```
